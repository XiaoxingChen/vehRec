# Keil uVision project Project.uvprojx, settings and files
target SY-STM32F407 V2.0 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --cpp --cpp11
  c include: ..\Libraries\CMSIS\inc;..\Libraries\FWlib\inc;..\Startup;..\User;..\Logger
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: stm32f4xx_it.c main.cpp CommonConfig.c CUsart.cpp CCan.cpp stmflash.c Timer.cpp
  group FWlib
    ../Libraries/FWlib/src/: misc.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_can.c stm32f4xx_iwdg.c stm32f4xx_flash.c
  group CMSIS
    ../Libraries/CMSIS/src/: system_stm32f4xx.c
  group Startup
    ../Startup/: startup_stm32f4xx.s
  group doc
    ./: logic.py
  group logger
    ../Logger/: CCanConsole.cpp Console.cpp CUartConsole.cpp rtt_vsnprintf.c SEGGER_RTT.c
software components: CMSIS:CORE 4.3.0
